# IAR project PLC.ewp, settings and files
configuration PLC (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746IG ST STM32F746IG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; __FPU_PRESENT; ARM_MATH_CM7; STM32F746xx; ARM_MATH_ROUNDING
  ICCARM.CCIncludePath2: ../Inc; ../Utilities/Fonts; ../Drivers/STM32F7xx_HAL_Driver/Inc; ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FatFs/src/drivers; ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Inc; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F7xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: PLC.hex
  ILINK.IlinkOutputFile: PLC.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f746xx.s
  group Application/User
    ../Src/: adc.c ARIALB_16pt.c bsp_driver_sd.c bsp_driver_sdram.c calculations.c can.c core.c dac.c DispInfo.c dma.c dma2d.c fatfs.c files.c fmc.c GOST_B_23_var.c gpio.c gui.c i2c.c ImageControl.c initial.c InputsTW.c interrupts.c keyboard.c lcd.c leds.c lm75.c ltdc.c main.c memory.c OSDBasic.c OSDFont.c OSDinitTable.c PTZinterface.c RIAD_16pt.c RIAD_20pt.c RIAD_30pt.c RIAD_40pt.c RIAD_80pt.c rtc.c sdmmc.c sound.c spi.c spi_mem.c stm32f7xx_hal_msp.c stm32f7xx_it.c stmpe811.c systimer.c tim.c timer11.c timer13.c timer14.c tw8819.c usart.c usb_host.c usbh_conf.c video.c visual_kbd.c
    ../Inc/: delays.h
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_adc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_can.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dac.c stm32f7xx_hal_dac_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_hcd.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_nand.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_spi.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c sdram_diskio.c usbh_diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    ../Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
